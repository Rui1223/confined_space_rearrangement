Commit message: identify the urdf change

File: urdf/motoman.urdf (robot description, URDF)
Before this commit: robot sda10f, 32 links, 31 joints
Joints:
- joint arm_right_joint_tool0: origin xyz=0 0 -0.025 rpy=0 0 -3.13 -> xyz=0 0 -0.055 rpy=0 0 -3.13
